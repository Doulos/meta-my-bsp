FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://linux-demo-imx93.sh"

